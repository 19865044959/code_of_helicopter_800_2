# Keil uVision project helicopter.uvprojx, settings and files
target helicopter (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767VGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: helicopter
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,ARM_MATH_CM7,__FPU_PRESENT=1
  c misc: --C99
  c include: ../Inc;   ../Drivers/STM32F7xx_HAL_Driver/Inc;   ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;   ../Middlewares/Third_Party/FatFs/src/drivers;   ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;   ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;   ../Middlewares/Third_Party/FatFs/src;   ../Middlewares/Third_Party/FreeRTOS/Source/include;   ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;   ../Drivers/CMSIS/Include;   ../User
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_gpio.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_rcc_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_tim.c stm32f7xx_hal_i2c.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c tasks.c croutine.c queue.c event_groups.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Application/User
    ../Src/: usart.c freertos.c stm32f7xx_it.c dma.c stm32f7xx_hal_timebase_TIM.c sdmmc.c tim.c stm32f7xx_hal_msp.c fatfs.c bsp_driver_sd.c gpio.c main.c spi.c i2c.c adc.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
  group User
    ../User/: command.c sdcard.c system.c userlib.c adis16365.c ahrs.c bell.c exit.c gps.c motor.c mpu6050.c ms5611.c parameter.c pid.c rc.c transfer.c control_manual.c control_stabilize.c control_poshold.c helicopter.c flight_mode.c gps_ins_EKF.c trajectory.c target.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
